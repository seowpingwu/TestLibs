# Keil uVision project SIAQM.uvprojx, settings and files
target SIAQM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SIAQM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\FWLIB\inc;..\FWLIB\src;..\UserINC;..\UserSRC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_exti.c
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group UserSRC
    ../UserSRC/: main.c mcu_i2c.c mcu_delay.c sgp30.c OLEDx.c mcu_spi.c nrf24l01.c sysled.c syskey.c sys_usart.c esp8266.c sht3x.c
  group UserINC
    ../UserINC/: mcu_delay.h stm32f10x_conf.h mcu_gpio.h mcu_i2c.h sgp30.h oledx.h font.h mcu_spi.h nrf24l01.h sysled.h syskey.h sys_usart.h sys_bmp.h bmp.h esp8266.h sht3x.h
  group Doc
    ../Doc/: Readme.txt
