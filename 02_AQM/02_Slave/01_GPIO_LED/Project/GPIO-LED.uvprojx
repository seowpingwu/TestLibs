# Keil uVision project GPIO-LED.uvprojx, settings and files
target GPIO-LED (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO-LED
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\STARTUP;..\CMSIS;..\FWLIB\inc;..\UserSRC;..\UserINC;..\UserSRC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../STARTUP/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group UserSRC
    ../UserSRC/: main.c sys_led.c sys_delay.c
  group UserINC
    ../UserINC/: stm32f10x_conf.h sys_delay.h sys_led.h
